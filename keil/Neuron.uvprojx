# Keil uVision project Neuron.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: M0516LAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.4
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Neuron +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M051Series\Include;..\Library\StdDriver\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Neuron
    ./: startup_M051Series.s
    ../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group src
    ../src/: main.c uart_printf.c systime.c mygpio.c protocol.c MePwm.c Interrupt.c sysinit.c dataflash.c smartservo.c
  group inc
    ../inc/: uart_printf.h systime.h mygpio.h protocol.h MePwm.h Interrupt.h sysinit.h dataflash.h smartservo.h
  group Library
    ../Library/StdDriver/src/: retarget.c sys.c uart.c i2c.c timer.c clk.c gpio.c fmc.c pwm.c
