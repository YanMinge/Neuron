# Keil uVision project Neuron.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: (Generic) M051 Series Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Neuron +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M051Series\Include;..\Library\StdDriver\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Neuron
    ./: startup_M051Series.s
    ../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group src
    ../src/: main.c uart_printf.c systime.c MeRGBLed.c mygpio.c
  group inc
    ../inc/: uart_printf.h systime.h MeRGBLed.h mygpio.h
  group Library
    ../Library/StdDriver/src/: retarget.c sys.c uart.c i2c.c timer.c clk.c gpio.c
